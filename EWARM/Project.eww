<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\stm32_i2c_driver.ewp</path>
  </project>
  <batchBuild />
</workspace>
